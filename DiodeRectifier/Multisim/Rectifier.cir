** Rectifier **
*
* NI Multisim to SPICE Netlist Export
* Generated by: caleb_000
* Wed, Jul 11, 2018 14:50:30
*

*## Multisim Component Vin ##*
vVin 5 0 dc 5 ac 0 0
+           distof1 0 0
+           distof2 0 0

*## Multisim Component Vss ##*
vVss Vss 0 dc -15

*## Multisim Component Vdd ##*
vVdd Vdd 0 dc 15

*## Multisim Component VCC ##*
VCCVCC  VCC 0 dc 15

*## Multisim Component VEE ##*
VEEVEE  VEE 0 dc -15

*## Multisim Component U1 ##*
xU1 0 4 VCC VEE Vout 5T_VirtualU1 params: Vos=0.001 Ibias=8e-008 Ioffset=2e-008 Av=200000 BW=100000000 SR=1000000 CMRR=100 Iomax=0.025 Rin=10000000 Rout=10

.subckt 5T_VirtualU1  In_p In_n Vpos Vneg Out params: Av=200k BW=20Meg CMRR=100
+SR=1Meg Rout=75 Iomax=25m Rin=100meg Vos=0.1m Ibias=1n Ioffset=1p
.param Rp1=1e6
.param Rs1=1e6
.param K_Is2a=sqrt(Av)/Rs1
.param K_Is2b=sqrt(Av)/Rp1
.param Cp1={Av/(2*pi*BW*Rp1)}
.param CMRR_lin=10**(CMRR/20)

Rin In_p In_n {Rin}
Bcm 4 3 V = { V(cm)/CMRR_lin}
Voff In_p 4 {Vos}
Ibias1 In_p 0 {Ibias}
Ibias2 In_n 0 {Ibias}
Ioffset In_p In_n {Ioffset/2}

Rcm1 In_p cm 10meg
Rcm2 In_n cm 10meg

BIs1a vref vs2a I = { K_Is2a*(V(3)-V(In_n)) }
Rs1 vs2a vref {Rs1}

BIs2b vref vs2b I = { K_Is2b*(V(vs2a)-v(vref)) }
Rp1 vs2b vref {Rp1}
VCp1sense vs2b vs2b_ 0
Cp1 vs2b_ vref {Cp1}

D3 vs2b_ 8 Limit_Diode
D4 8 vpos Limit_Diode
B_SRp 8 vpos I={I(VCp1sense)- (Cp1*SR)}

D5 10 vs2b_ Limit_Diode
D6 Vneg 10 Limit_Diode
B_SRn Vneg 10 I={-1*I(VCp1sense)-(Cp1*SR)}

DVpclip vs2b_ Vpos V_limit
DVnclip Vneg vs2b_ V_limit

Bout vref out_ I={(V(vs2b)-v(vref))/Rout}
Rout vref out_ {Rout}
Voutsense out_ out 0

D9 out 15 Limit_Diode
D10 15 vpos Limit_Diode
B_outp 15 vpos I={I(Voutsense)- Iomax}

D11 16 out Limit_Diode
D12 vneg 16 Limit_Diode
B_outn vneg 16 I={-1*I(Voutsense)-Iomax}

R5 Vpos mid 1000000
R6 mid Vneg 1000000
Eref vref 0 mid 0 1

.MODEL Limit_Diode  D (IS= 1.0e-12)
.MODEL V_limit D(n=0.1)
.ends

*## Multisim Component R4 ##*
rR4 2 Vss 5100 vresR4
.model vresR4 r(  )

*## Multisim Component D4 ##*
dD4 4 2 DIODE__DIODES_VIRTUAL__1__1

*## Multisim Component D3 ##*
dD3 3 4 DIODE__DIODES_VIRTUAL__1__1

*## Multisim Component D2 ##*
dD2 1 2 DIODE__DIODES_VIRTUAL__1__1

*## Multisim Component D1 ##*
dD1 3 1 DIODE__DIODES_VIRTUAL__1__1

*## Multisim Component R3 ##*
rR3 Vdd 3 5100 vresR3
.model vresR3 r(  )

*## Multisim Component R2 ##*
rR2 4 Vout 3000 vresR2
.model vresR2 r(  )

*## Multisim Component R1 ##*
rR1 5 1 1000 vresR1
.model vresR1 r(  )

.model DIODE__DIODES_VIRTUAL__1__1  D
+ (
+  IS=1.261e-014 N=1.8 BV=100
+ )

.DC vVin -5 5 0.01
.PROBE
.END
